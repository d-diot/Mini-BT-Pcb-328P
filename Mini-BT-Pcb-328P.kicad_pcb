# Repository d-diot/Mini-BT-Pcb-328P

File README.md:

# d-diot Mini-BT-Pcb-328P

This board is part of the [d-diot project](https://www.d-diot.com).
See the [blog post](https://www.d-diot.com/2020/02/08/mini-bt-pcb-328p/) or the dedicated [wiki page](https://wiki.d-diot.com/hardware/pcb/mysensors/mini-bt-pcb-328p) to know more about this board.

See the latest [release](https://github.com/d-diot/Mini-BT-Pcb-328P/releases) to download the gerber files to manufacture this board.

## Applications of this PCB:

### Doors and Windows sensor
[MySensors](https://www.mysensors.org/) battery powered and [3d printable](https://www.thingiverse.com/thing:4179099) wireless [doors and windows sensor](https://wiki.d-diot.com/sensors_and_actuators/mysensors/door_window_sensor).
MySensors is compatible with a lot of open source home automation software like Home Assistant (which is the one included in the [d-diot hub](https://www.d-diot.com/2020/05/24/d-diot-hub-v-2-0/) and [image](https://www.d-diot.com/?s=d-diot+image)), OpenHAB, Domoticz, etc... See [here](https://www.mysensors.org/controller) for a complete list.

### Soil moisture sensor
[MySensors](https://www.mysensors.org/) battery powered and [3d printable](https://www.thingiverse.com/thing:4280183) wireless [soil moisture sensor](https://wiki.d-diot.com/sensors_and_actuators/mysensors/soil_moisture_sensor).

## Firmware

The [repository](https://github.com/d-diot/Mini-BT-Pcb-328P-firmware) of the firmware associated to this board is here.

## KiCad design Mini-BT-Pcb-328P.kicad_pcb

Parts:
BT1: CR2032; BatteryHolder_Keystone_1058_1x2032
BT2, BT3: AAA Cell; AAA-Keystone-55
C1: 100uF; CP_Elec_6.3x5.4
C2: 100uF-Tantalum; TAJD107K016RNJV
C3, C6: 10uF; C_0805_2012Metric
C4, C7, C8, C9, C10, C11: 0.1uF; C_0805_2012Metric
C5: 22uF-Tantalum; CAPPC3528X210N
C12: 47uF; CP_Elec_5x5.4
D1: SS14
D2: R-LED; LED_0805_2012Metric
D3, D5: Y-LED; LED_0805_2012Metric
D4: G-LED; LED_0805_2012Metric
J1: Analog IN; PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Left
J2: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J3: Booster CE; PinHeader_2x03_P2.54mm_Vertical_SMD
J5: ANT; PinHeader_1x01_P2.54mm_Vertical
JP1: Boost; PinHeader_1x03_P2.54mm_Vertical_SMD_Pin1Left
JP2: Radio-rst; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 22uH; L_6.3x6.3_H3
P1: MYSX_2.6; PinHeader_2x11_P2.54mm_Vertical_SMD
Q1: FDN338P; SSOT-3
Q2: FDN337N; SSOT-3
R1, R4: 20K; R_0805_2012Metric
R2, R3, R5, R9: 10K; R_0805_2012Metric
R6, R7, R8, R10: 330; R_0805_2012Metric
SW2: Reset; SW_1437566-3
SW3: SW_Reed; Reed-MKA-14103
U1: ME2188C33; SOT-23-5
U2: ATSHA204A; SOT-23_Handsoldering
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
U5: NRF24L01
U6: NRF24L01; NRF24L01-SMD
U7: RFM69HW; RFM69HW_SMD_Handsoldering

Connections:
+3.3V: C2.1, JP1.3 (B), P1.2 (+3.3V), U1.2 (VOUT)
A0: D2.1 (K), P1.15 (D9_A3), U4.23
A1: D3.1 (K), P1.16 (D10_A4), U4.24
A2: D4.1 (K), P1.21 (A5), U4.25
A3: P1.22 (A6), R2.2, U2.1 (SDA), U4.26
A4-SDA: P1.14 (D8_SDA), U4.27
A5-SCL: P1.13 (D7_SCL), U4.28
A6: J1.1, U4.19
A7: J1.2, U4.22; also elsewhere on the board
D0-RXD: P1.6 (D2_DTM), U4.30
D1-TXD: P1.5 (D1_DFM), U4.31
D2: P1.9 (D3_INT), U4.32, U5.8 (IRQ), U6.8 (IRQ), U7.2 (DIO0)
D3: P1.10 (D4_INT), SW3.1, U4.1
D4: J3.3, U4.2
D5: P1.11 (D5_PWM), U4.9
D6: P1.12 (D6_PWM), U4.10
D8: R10.2, U4.12
D9: JP2.1 (A), U4.13, U5.3 (CE), U6.3 (CE)
DTR: C11.2, P1.8 (LEGACY_ID)
Ext-Pwr-Sense: Q2.3 (D), R4.1, U4.11
GND: BT1.2 (-), BT3.2 (-), C1.2, C2.2, C3.1, C4.1, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C12.2, D5.1 (K), J2.5 (GND), JP2.3 (B), P1.4 (GND), Q2.2 (S), R3.1, R9.1, SW2.1, SW3.2, U1.4 (GND), U2.3 (GND), U3.1 (GND), U4.3, U4.5, U4.21, U5.1 (GND), U6.1 (GND), U7.9 (GND), U7.11 (GND); also elsewhere on the board
MISO: P1.18 (D12_MISO), U4.16, U5.7 (MISO), U6.7 (MISO), U7.13 (MISO)
MOSI: P1.17 (D11_MOSI), U4.15, U5.6 (MOSI), U6.6 (MOSI), U7.14 (MOSI)
NSS: P1.20 (D14_CS), U4.14, U5.4 (CSN), U6.4 (CSN), U7.15 (NSS)
unnamed 24: BT1.1 (+), BT2.1 (+), C1.1, Q1.3 (D); also elsewhere on the board
unnamed 25: BT2.2 (-), BT3.1 (+); also elsewhere on the board
unnamed: C3.2, JP1.1 (A), L1.1, Q1.2 (S), R1.2
unnamed: C5.1, D1.2 (A), Q1.1 (G), Q2.1 (G), R3.2, U3.2 (VO)
unnamed: C6.1, J2.1 (VBUS), JP3.2 (B), U3.3 (VI)
unnamed: C7.1, U4.20
unnamed: D2.2 (A), R6.1
unnamed: D3.2 (A), R7.1
unnamed: D4.2 (A), R8.1
unnamed: D5.2 (A), R10.1
unnamed: J3.1, R9.2
unnamed: J3.2, J3.4, J3.6, U1.1 (CE)
unnamed: J3.5, R1.1
unnamed: J5.1, U7.10 (ANA)
unnamed: JP2.2 (C), U7.1 (RESET)
unnamed: L1.2, U1.5 (LX)
RESET: C11.1, P1.7 (RST), R5.1, SW2.2, U4.29
SCK: P1.19 (D13_SCK), U4.17, U5.5 (SCK), U6.5 (SCK), U7.12 (SCK)
VCC: C4.2, C8.2, C9.2, C10.2, C12.1, D1.1 (K), JP1.2 (C), P1.3 (VCCio), R2.1, R4.2, R5.2, R6.2, R7.2, R8.2, U2.2 (VCC), U4.4, U4.6, U4.18, U5.2 (VCC), U6.2 (VCC), U7.8 (3.3V)
Vin: JP3.1 (A), P1.1 (Vraw)

Board: 2 copper layers, 55.0 x 35.0 mm, 52 parts (26 on the bottom side), 44 nets.

Other parts of the board:
JP4: 1xAAA; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP5: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm

Their connections:
A7: JP5.1; also elsewhere on the board
GND: JP4.2; also elsewhere on the board
unnamed 24: JP5.2; also elsewhere on the board
unnamed 25: JP4.1; also elsewhere on the board

## Commit log

2019-10-06 Routing traces 1
2019-10-06 added README.md
2019-10-06 routing test 2
2019-10-06 routing test 3
2019-10-08 routing test 4
2019-10-10 routing test 5
2019-10-10 routing test 6
2019-10-11 finalization 1
2019-10-11 Mini-BT-Pcb-328P v.1.0
2020-02-09 version 2.0
2020-05-31 Mini-BT-Pcb-328P v.2.0 release
2020-07-15 added gerber files suitable for manufacturing with PCBWay
